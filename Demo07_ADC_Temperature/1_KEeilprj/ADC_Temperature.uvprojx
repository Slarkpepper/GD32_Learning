# Keil uVision project ADC_Temperature.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC_Temperature +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, GD32F450
  c include: ..\2_Source\Bsp;..\2_Source\CMSIS;..\2_Source\Library\Include;..\2_Source\RTE;..\2_Source\User;..\2_Source\Utilities;..\2_Source\HardWare\ADC;..\2_Source\HardWare\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../2_Source/CMSIS/: system_gd32f4xx.c
  group Hardware
    ../2_Source/HardWare/LED/: led.c
    ../2_Source/HardWare/ADC/: adc.c
  group Library
    ../2_Source/Library/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../2_Source/Startup/: startup_gd32f450_470.s
  group User
    ../2_Source/User/: gd32f4xx_it.c main.c systick.c
  group Utilities
    ../2_Source/Utilities/: gd32f450z_eval.c
software components: CMSIS:CORE 5.1.2
